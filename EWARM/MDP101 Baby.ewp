# IAR project MDP101 Baby.ewp, settings and files
configuration MDP101 Baby (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: C:\Users\Alexander Anisimov\Documents\PRIBORE ELECTRONICS\MIDI Project\MDP101 Baby/Inc; C:\Users\Alexander Anisimov\Documents\PRIBORE ELECTRONICS\MIDI Project\MDP101 Baby/Drivers/STM32F1xx_HAL_Driver/Inc; C:\Users\Alexander Anisimov\Documents\PRIBORE ELECTRONICS\MIDI Project\MDP101 Baby/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; C:\Users\Alexander Anisimov\Documents\PRIBORE ELECTRONICS\MIDI Project\MDP101 Baby/Drivers/CMSIS/Device/ST/STM32F1xx/Include; C:\Users\Alexander Anisimov\Documents\PRIBORE ELECTRONICS\MIDI Project\MDP101 Baby/Drivers/CMSIS/Include; C:\Users\Alexander Anisimov\Documents\PRIBORE ELECTRONICS\MIDI Project\MDP101 Baby/Middlewares/ST/STM32_USB_Device_Library/Core/Inc; C:\Users\Alexander Anisimov\Documents\PRIBORE ELECTRONICS\MIDI Project\MDP101 Baby/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; C:\Users\Alexander Anisimov\Documents\PRIBORE ELECTRONICS\MIDI Project\MDP101 Baby/Json; C:\Users\Alexander Anisimov\Documents\PRIBORE ELECTRONICS\MIDI Project\MDP101 Baby\bootloader\inc; C:\Users\Alexander Anisimov\Documents\PRIBORE ELECTRONICS\MIDI Project\MDP101 Baby\pribore.com\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MDP101 Baby.hex
  ILINK.IlinkOutputFile: MDP101 Baby.out
  ILINK.IlinkIcfFile: C:\Users\Alexander Anisimov\Documents\PRIBORE ELECTRONICS\MIDI Project\MDP101 Baby\EWARM\stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
  group application/User
    ../Src/: adc.c Init.c keyboard.c main.c midi_baby.c queue.c software_timer.c stm32f1xx_it.c task.c tim.c usb_device.c usbd_conf.c usbd_desc.c usbd_midi_if.c usr_led_blnk.c
  group bootloader
    ../bootloader/src/: bootloader.c
  group drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c
  group json
    ../Json/: jsmn.c
  group midi
    ../Src/: midi.c midi_ble.c
  group mpu6050_gyro_accel
    ../Src/: mpu6050_ll_driver.c mpu6050_ll_selt_test.c
  group usb core
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_midi.c
